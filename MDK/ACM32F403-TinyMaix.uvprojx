# Keil uVision project ACM32F403-TinyMaix.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ACM32F403-TinyMaix +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\HAL_Driver\Inc;..\APP;..\TinyMaix;..\TinyMaix\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group CMSIS
    ../Core_Drivers/CMSIS/: core_cm33.h
  group Device
    ../Core_Drivers/Device/: System_ACM32F4.c Startup_ACM32F4.s System_Accelerate.lib
  group HAL
    ../Core_Drivers/HAL_Driver/Src/: HAL_GPIO.c HAL_TIMER.c HAL_UART.c HAL_EFlash.c HAL_EFlash_EX.lib HAL_DMA.c
  group APP
    ../APP/: main.c timer.c
  group TinyMaix
    ../TinyMaix/: tm_layers.c tm_layers_O1.c tm_model.c tm_stat.c
